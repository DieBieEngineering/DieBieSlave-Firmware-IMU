# Keil uVision project DieBieSlave.uvprojx, settings and files
target DieBieSlave (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F303RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x08000000-0x807FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4")
  output: DieBieSlave +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xE
  c misc: --C99
  c include: ..\Device\Src;..\Device\Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;..\Drivers\HWDrivers\Inc;..\Drivers\HWDrivers\Src;..\Drivers\SWDrivers\Inc;..\Drivers\SWDrivers\Src;..\Modules\Inc;..\Modules\Src;..\Libraries\Inc;..\Libraries\Src;..\Middlewares\SSC\Inc;..\Middlewares\SSC\Src;..\ObjDictionary\Inc;..\ObjDictionary\Src;..\Middlewares\DieBie\Inc;..\Middlewares\DieBie\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400
  memory RVCT5: ROM 0x8001800 size 0x1e800
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/HALDriver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_uart.c stm32f3xx_hal_flash.c stm32f3xx_hal_gpio.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_dma.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cortex.c
  group Drivers/HWDriver
    ../Drivers/HWDrivers/Src/: driverHWECATTickTimer.c driverHWEEPROM.c driverHWLANInterrupt.c driverHWStatus.c driverHWSPI1.c driverHWSPI3.c driverHWI2C3.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Driver/SWDriver
    ../Drivers/SWDrivers/Src/: driverSWLAN9252.c driverSWMPU9250.c driverSWNunChuck.c driverSWStorageManager.c
  group Middlewares/SSC
    ../Middlewares/SSC/Src/: esc.c esc_coe.c esc_foe.c objectlist.c middleSOES.c
  group Middlewares/USB
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group MiddleWares
    ../Middlewares/DieBie/Src/: middleMPU.c middleNunChuck.c
  group Modules
    ../Modules/Src/: modConfig.c modDelay.c modEffect.c
  group Device
    ../Device/: startup_stm32f303xe.s
    ../Device/Src/: stm32f3xx_hal_msp.c stm32f3xx_it.c system_stm32f3xx.c
    ../Device/Inc/: dataHelper.h
  group Main
    ../Main/: main.c
software components: CMSIS:CORE 4.1.0
